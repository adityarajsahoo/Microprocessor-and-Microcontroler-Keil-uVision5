// Rolling

L:SETB P1.0
ACALL DELAY
CLR P1.0
SETB P1.1
ACALL DELAY
CLR P1.1
SETB P1.2
ACALL DELAY
CLR P1.2
SETB P1.3
ACALL DELAY
CLR P1.3
SETB P1.4
ACALL DELAY
CLR P1.4
SETB P1.5
ACALL DELAY
CLR P1.5
SETB P1.6
ACALL DELAY
CLR P1.6
SETB P1.7
ACALL DELAY
CLR P1.7
SJMP 1
DELAY:MOV R1,#05H
L1:DJNZ R1,L1
RET
END
