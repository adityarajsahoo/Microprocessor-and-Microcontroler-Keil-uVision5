L:MOV A,#02H
MOV B,#02H
MUL AB
MOV B,#02H
MUL AB
MOV B,#06H
MUL AB
MOV R0,A
MOV A,#03H
MOV B,#03H
MUL AB
MOV B,#02H
MUL AB
MOV R1,A
MOV A,#03H
MOV B,#03H
MUL AB
MOV R2,A
ACALL DELAY
SJMP L

DELAY: ADD A,R0
ADD A,R1
SUBB A,R2
L1: DJNZ R1,L1
RET
END     //19BEI0086 ADITYA RAJ SAHOO
